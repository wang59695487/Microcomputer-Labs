# Keil uVision project eleclock.uvproj, settings and files
target elcclock (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: eleclock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\inc
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/src/: ds1302.c lcd.c globalvar.c key.c 51it.c temp.c
